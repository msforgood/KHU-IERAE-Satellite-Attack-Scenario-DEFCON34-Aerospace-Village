options:
  parameters:
    author: sunhyuk
    category: Custom
    description: ENIGMA-1 AX.25/G3RUH 9600 decoder (Scenario 1)
    generate_options: qt_gui
    id: enigma1_decoder
    output_language: python
    run_options: run
    title: ENIGMA-1 Decoder
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 0.05e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/sunhyuk/projects/vsa4lv-defcon/vsa4lv-challenges/scenario-1/signal/ENIGMA-1_433_506MHz_2026-07-08T02-25-04.cf32
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block: ENIGMA-1 image reassembler.

      Receives decoded AX.25 UI frames (PDUs) from the gr-satellites ax25_deframer,
      takes each Info field = [2-byte big-endian sequence][payload chunk], orders the
      chunks by sequence, strips the 4-byte length prefix, DEFLATE-inflates the result
      and writes the recovered grayscale image.
      """
      import struct
      import zlib
      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, img_w=192, img_h=128, out_path='/home/sunhyuk/projects/vsa4lv-defcon/vsa4lv-challenges/scenario-1/solution/enigma1_recovered.png'):
              gr.sync_block.__init__(self, name='ENIGMA-1 Image Reassembler',
                                     in_sig=[], out_sig=[])
              self.w, self.h = int(img_w), int(img_h)
              self.out_path = out_path
              self.chunks = {}
              self.done = False
              self.message_port_register_in(pmt.intern('frame'))
              self.set_msg_handler(pmt.intern('frame'), self.handle)

          def handle(self, msg):
              if self.done:
                  return
              try:
                  ba = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              except Exception:
                  return
              if len(ba) <= 16:            # 7+7 addr + ctrl + pid = 16-byte header
                  return
              info = ba[16:]               # ax25_deframer already strips the FCS
              if len(info) < 2:
                  return
              seq = struct.unpack('>H', info[:2])[0]
              self.chunks.setdefault(seq, info[2:])
              ordered, k = b'', 0
              while k in self.chunks:
                  ordered += self.chunks[k]; k += 1
              if len(ordered) < 4:
                  return
              clen = struct.unpack('>I', ordered[:4])[0]
              if len(ordered) < 4 + clen:
                  return
              try:
                  data = zlib.decompress(ordered[4:4 + clen])
              except zlib.error:
                  return
              if len(data) != self.w * self.h:
                  return
              try:
                  from PIL import Image
                  Image.frombytes('L', (self.w, self.h), data).save(self.out_path)
              except Exception:
                  with open(self.out_path + '.raw', 'wb') as fh:
                      fh.write(data)
              self.done = True
              print('[ENIGMA-1] IMAGE DECODED -> ' + self.out_path)

          def work(self, input_items, output_items):
              return 0
    img_h: '128'
    img_w: '192'
    out_path: '''/home/sunhyuk/projects/vsa4lv-defcon/vsa4lv-challenges/scenario-1/solution/enigma1_recovered0708.png'''
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 12000, 2000)
    type: ccc
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: '""'
    name: '"ENIGMA-1 433.5 MHz"'
    type: complex
  states: {state: disabled}
- name: satellites_ax25_deframer_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baud_rate
    iq: 'True'
    options: '"--deviation " + str(deviation)'
    samp_rate: samp_rate
    subaudio: 'False'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', satellites_fsk_demodulator_0, '0']
- [satellites_ax25_deframer_0, out, blocks_message_debug_0, log]
- [satellites_ax25_deframer_0, out, epy_block_0, frame]
- [satellites_fsk_demodulator_0, '0', satellites_ax25_deframer_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
